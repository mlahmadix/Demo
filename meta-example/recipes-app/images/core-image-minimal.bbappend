IMAGE_INSTALL += " dropbear tcf-agent demo-auto"
